# IAR project Gascan.ewp, settings and files
configuration CC2540 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=FALSE; HAL_ADC=TRUE; HAL_UART=TRUE; DEBUG_PRINT
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; ..\Source\drv; ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540-UBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=TRUE; HAL_UART=TRUE; DEBUG_PRINT; OAD_KEEP_NV_PAGES; FEATURE_UBL_MSD
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-UBL\Exe\Balance-UBL"
  XLINK.XclFile: cc254x_f256_ubl_msd.xcl
configuration CC2540-imgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_ADC=TRUE; HAL_UART=TRUE; DEBUG_PRINT
  ICC8051.CCIncludePath2: ..\Source; ..\Source\drv; ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA_small_this.xcl
configuration CC2540-imgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; xFEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; HAL_ADC=TRUE; HAL_UART=TRUE; DEBUG_PRINT
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-ImgB\Exe\Balance"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB_Large_this.xcl
configuration CC2540-release (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=FALSE; HAL_ADC=TRUE; HAL_UART=FALSE; xDEBUG_PRINT
  group APP
    ../Source/: BleComm.c BleComm.h Gascan.c Gascan.h Gascan_Main.c OSAL_Gascan.c Packet.c Packet.h Parameter.c Parameter.h peripheral_small.c Protocol.h
  group driver
    ../Source/drv/: 24Cxx.c 24Cxx.h EEPROM.h gpio.h HX711.c HX711.h I2C.c I2C.h Indicator.c Indicator.h Meter.c Meter.h pindefine.h Pressure.c Pressure.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../Profiles/SimpleProfile/: gascanGATTprofile.c gascanGATTprofile.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
