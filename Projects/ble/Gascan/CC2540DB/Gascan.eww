<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Gascan.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Gascan</project>
        <configuration>CC2540</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


